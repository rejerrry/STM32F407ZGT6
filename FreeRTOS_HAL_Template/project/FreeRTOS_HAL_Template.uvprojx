# Keil uVision project FreeRTOS_HAL_Template.uvprojx, settings and files
target FreeRTOS_HAL_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LL_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\libraries\cmsis;..\libraries\STM32F4xx_HAL_Driver\Src;..\libraries\STM32F4xx_HAL_Driver\Inc;..\user;..\user\framework\drivers;..\user\framework\drivers\tftlcd;..\libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\libraries\STM32F4xx_HAL_Driver\Inc\Legacy;..\user\src;..\user\inc;..\freertos\portable;..\freertos\portable\RVDS;..\freertos\portable\MemMang;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../libraries/cmsis/: startup_stm32f407xx.s
  group cmsis
    ../libraries/cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group hal
    ../libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c
  group user
    ../user/src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim_template.c
    ../user/inc/: bsp_system.h
  group doc
    ../doc/: readme.txt 笔记.txt
  group fr/drivers
    ../user/framework/drivers/: drv_beep.c drv_ds18b20.c drv_exti.c drv_input.c drv_iwdg.c drv_key.c drv_led.c drv_pwm.c drv_rcc.c drv_systick.c drv_tick.c drv_timer.c drv_uart.c drv_wwdg.c system.c
  group fr/drivers/tftlcd
    ../user/framework/drivers/tftlcd/: picture.h font.h drv_tftlcd.c
  group freertos/src
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/port
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
