# Keil uVision project FreeRTOS_LL_Template.uvprojx, settings and files
target FreeRTOS_LL_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LL_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\libraries\cmsis;..\libraries\fwlib\inc;..\libraries\fwlib\src;..\user;..\user\framework\drivers;..\user\framework\drivers\tftlcd;..\freertos\portable;..\freertos\portable\RVDS;..\freertos\portable\MemMang;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../libraries/cmsis/: startup_stm32f40_41xxx.s
  group cmsis
    ../libraries/cmsis/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group fwlb
    ../libraries/fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c bsp_system.h
    ../freertos/include/: FreeRTOSConfig.h
  group doc
    ../doc/: readme.txt readme_CN.txt
  group fr/drivers
    ../user/framework/drivers/: drv_led.c drv_port.h drv_rcc.c drv_tick.c drv_beep.c drv_exti.c drv_key.c drv_pwm.c drv_timer.c drv_uart.c system.c drv_ds18b20.c drv_input.c drv_iwdg.c drv_systick.c drv_wwdg.c
  group fr/drivers/tftlcd
    ../user/framework/drivers/tftlcd/: drv_tftlcd.c font.h picture.h
  group freertos/src
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/port
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
